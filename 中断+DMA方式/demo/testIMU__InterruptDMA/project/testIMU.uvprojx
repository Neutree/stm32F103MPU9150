# Keil uVision project testIMU.uvprojx, settings and files
target IMUtest (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: testIMU +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPEREPH_DRIVER,STM32F10X_MD
  c include: ..\usr\app;..\usr\bsp;..\usr\sys;.\RTE\Device\STM32F103ZE;.\RTE;..\usr\bsp\STM32_CPAL_Driver\inc;..\usr\bsp\STM32_CPAL_Driver\src;..\usr\bsp\STM32_CPAL_Driver\devices\stm32f10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ../usr/sys/: main.cpp
  group app
    ../usr/app/: queue.c
  group bsp
    ../usr/bsp/: delay.c usart.c iic.c IMU.cpp HAL_IMU.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
